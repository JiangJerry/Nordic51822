# Keil uVision project experimental_ble_app_uart_s110_pca10028.uvproj, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nrf51422_xxac_s110 +hex
  c flags: Optim=4 OneElfS=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10001 BOARD_PCA10028
  c misc: --c99
  c include: ..\..\..\..\..\components\toolchain;..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\drivers_nrf\simple_uart;..\..\..\..\..\components\libraries\button;..\..\..\..\bsp;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\toolchain\gcc
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Application
    ../../: ble_nus.c main.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_BLE_Modules
    ../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/simple_uart/: simple_uart.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../components/libraries/timer/: app_timer.c
  group nRF_SoftDevice_Internal
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
