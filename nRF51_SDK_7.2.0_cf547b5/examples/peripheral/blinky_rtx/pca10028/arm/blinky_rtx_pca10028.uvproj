# Keil uVision project blinky_rtx_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 __STACK_SIZE=1024 NRF51 RTX BSP_DEFINES_ONLY BOARD_PCA10028
  c misc: --c99
  c include: ..\..\;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\libraries\util;..\..\..\..\..\external\rtx\include;..\..\..\..\bsp
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../../: main.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group lib
    ../../../../../external/rtx/source/ARM/: RTX_CM0.lib
    ../../: RTX_Conf_CM.c
